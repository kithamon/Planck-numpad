## boards/shields/planck_numpad/Kconfig.defconfig
```kconfig
if SHIELD_PLANCK_NUMPAD

config ZMK_KEYBOARD_NAME
    default "BCI NumPad"

endif
```
